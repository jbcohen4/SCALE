Title: OP27 Ios/Vos/Ib testbench
********************************

*Input Voltage Source
*********************
VCC 6 0 DC {Vcc}V
VEE 7 0 DC {Vee}V
*********************
*Subcircuit
*X1 26 22 27 28 25
X1 6 7 1 2 3 OP27

RR1 9 0 50
RR2 9 0 50
RR3 10 0 25
RR4 3 10 100k

*RR1 9 0 100k
*RR2 9 0 100k
*RR3 10 0 100k
*RR4 10 3 100k

VP 9 1 0
VM 10 2 0

*Input
********
.dc VCC 0 30 1

*Output
.print dc format=noindex file={output_filename}
+ V(6)
+ V(3)
+ {V(2)-V(1)}
+ {(I(VP)+I(VM))/2}
+ {I(VM)-I(VP)}
