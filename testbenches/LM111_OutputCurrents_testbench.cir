Title: LM111 / Prerad
*************************************

*Input Voltage Source
*********************
VCC 1 0 DC {Vcc}V
VEE 5 0 DC {Vee}V
VOUT 4 0 DC 1.4V
Vin1 2 0 DC 2.5V
Vin2 3 0 DC 1V

*Schematic name: LM111 core
***************************
*Subcircuit
*X1 {21 28 22 23 24} = {V_CC V_EE VIN+ VIN- V_OUT}
X1 1 5 2 3 4 LM111

*Input
******
.DC LIN VIN1 0 2 2

*Output
*******
.print dc format=noindex file={output_filename}
+ V(2)
+ I(VOUT)
