Title: OP27 / Positive Input Bias Current / Pre_Rad
***********************************************

*Power Supply Voltage Source
***************
VCC 7 0 DC {Vcc}V
VSS 1 0 DC {Vee}V

*Circuit Core
***************************
*Subcircuit: X1 4 76 69 6 14
X1 1 2 3 4 5 OP27

RINP 6 0 2MEG

*Input
VVCC 7 5 0
VP 3 6 0
VM 2 0 0

*Analysis
.dc VCC 0 15 1

*Output
.print dc format=noindex file={output_filename}
+ V(7)
+ I(VP)
