Title: LM117_Prerad
*********************************************************

*Input Voltage Source
*********************
VIN 1 0 DC 28V

R1 2 3 240
R2 3 0 767

*Schematic name: LM117
***************************
*Subcircuit
*X1 {VIN VOUT VADJ}
X1 1 2 3 LM117

*Input (ignore value at 0 V - that's for iol)
******
.DC LIN VIN 28 80 2.5

*Output
*******
.print dc format=noindex file={output_filename}
+ V(2)
+ V(3)
+ {V(2)-V(3)}
+ I(R2)
+ I(R1)
+ {I(R2)-I(R1)}
