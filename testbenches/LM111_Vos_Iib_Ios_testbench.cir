Title: LM111 / Vos, Iib, Ios
*************************************
*Voltage Source
VCC 4 0 DC 15V
VEE 5 0 DC -15V

Vout 8 0 5V
RP 8 3 1k

*********************
*Subcircuit LM111 Vcc Vee NonInvInput InvInput Output
X1 4 5 1 2 3 LM111

RR1 2 0 0
RR2 1 6 0
VP 6 0 DC 0V

*Input
.dc VP -1 1 0.0001

*Output
.print dc format=noindex file={output_filename}
+ V(6)
+ V(3)
+ {(I(RR2)+I(RR1))/2}
+ {I(RR2)-I(RR1)}
