Title: LM741 Ios/Vos/Ib testbench 1
********************************

*Input Voltage Source
*********************
VCC 8 0 DC 0V
VEE 7 0 DC -15V
*********************
*Subcircuit
*X1 26 22 27 28 25
X1 6 7 1 2 3 LM741
VVCC 8 6 0
VIN1 9 0 0
VIN2 10 0 0

RR3 1 9 9Meg
RR2 2 10 1Meg
RR1 2 3 10Meg
*Input
********
.dc VCC 0 30 1

*Output
.print dc format=noindex file={output_filename}
+ V(8)
+ V(3)
